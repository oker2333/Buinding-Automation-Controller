# Keil uVision project STM32F407.uvprojx, settings and files
target STM32 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F407 +hex
  AfterMake: "C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe" --strip=debug --bin --output ./Objects/STM32F407.bin ./Objects/STM32F407.axf
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER  STM32F40_41xxx
  c include: .\USER;.\CMSIS;.\FWLIB\inc;.\CMSIS\Include;.\HARDWARE\include;.\APP;.\UCOS-III\BSP;.\UCOS-III\uC-CPU;.\UCOS-III\uC-CPU\ARM-Cortex-M4\RealView;.\UCOS-III\uC-LIB;.\UCOS-III\uC-LIB\Ports\ARM-Cortex-M4\RealView;.\UCOS-III\uCOS-III;.\UCOS-III\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;.\UCOS-III\uCOS-III\Source
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\Objects\STM32F407.sct
  group APP
    ./APP/: app.c app_cfg.h cpu_cfg.h includes.h lib_cfg.h main.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h system_stm32f4xx.c system_stm32f4xx.h
  group FWLIB
    ./FWLIB/src/: misc.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4x7_eth.c stm32f4xx_dma.c stm32f4xx_i2c.c
  group STARTUP
    ./CMSIS/startup/: startup_stm32f40_41xxx.s
  group HARDWARE
    ./HARDWARE/source/: led.c rs485.c dma.c debug.c at24cxx.c lan8720.c
  group μCOS/BSP
    ./UCOS-III/BSP/: bsp.c bsp.h bsp_int.c bsp_periph.c
  group μCOS/uC-CPU
    ./UCOS-III/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
    ./UCOS-III/uC-CPU/ARM-Cortex-M4/RealView/: cpu.h cpu_a.asm cpu_c.c
  group μCOS/uC-LIB
    ./UCOS-III/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ./UCOS-III/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group μCOS/uC-SRC
    ./UCOS-III/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
    ./UCOS-III/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c
